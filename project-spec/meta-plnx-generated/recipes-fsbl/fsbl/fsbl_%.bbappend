
YAML_BSP_CONFIG[stdin] = "set,ps7_uart_1"
XSCTH_WS = "${TOPDIR}/../components/plnx_workspace"
XSCTH_REPO ?= "none"
YAML_BSP_CONFIG[stdout] = "set,ps7_uart_1"
export PETALINUX
YAML_BSP_CONFIG = "stdin stdout"
