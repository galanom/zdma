SRC_URI += "file://user_2017-06-26-16-50-00.cfg"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

