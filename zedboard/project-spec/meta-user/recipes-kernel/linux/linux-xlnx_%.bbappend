SRC_URI += "file://user_2017-06-08-20-07-00.cfg"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

