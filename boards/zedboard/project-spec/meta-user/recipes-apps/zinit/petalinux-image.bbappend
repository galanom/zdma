IMAGE_INSTALL_append = " zinit"
