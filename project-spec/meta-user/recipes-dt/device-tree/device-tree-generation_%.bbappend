SRC_URI_append ="\
    file://system-top.dts\
"
FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
